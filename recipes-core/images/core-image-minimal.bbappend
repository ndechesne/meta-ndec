

IMAGE_INSTALL += "kernel-modules e2fsprogs-resize2fs"

IMAGE_FSTYPES_append = " cpio.gz"
